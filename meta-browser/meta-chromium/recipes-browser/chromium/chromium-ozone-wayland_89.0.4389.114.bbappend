SRC_URI += " \
    file://0001-Remove-the-GN-settings-done-for-clang-that-conflict-.patch \
    file://0002-v8-qemu-wrapper.patch \
    file://0003-wrapper-extra-flags.patch \
    file://0004-BUILD-do-not-specify-march-on-arm.patch \
    file://0005-Consider-armv7ve-define.patch \
    file://0006-Delete-compiler-options-not-available-in-release-ver.patch \
    file://0008-Fix-sandbox-Aw-snap-for-syscalls-403-and-407.patch \
    file://0009-RandBytes-Stop-including-sys-random.h-on-Linux.patch \
    file://0010-avoid-link-latomic-failure-on-CentOS-8-host.patch \
    file://0011-Fix-use-of-DCHECK-with-std-unique_ptr.patch \
    file://0012-Fix-font-rendering-with-glibc-2.33.patch \
    file://0013-Only-DRI-for-x11.patch \
"

