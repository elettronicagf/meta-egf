RDEPENDS_${PN}_remove_mx6 = " \
     libasound-module-bluez \
     pulseaudio-module-bluetooth-discover \
     pulseaudio-module-bluetooth-policy \
     pulseaudio-module-bluez5-discover \
     pulseaudio-module-bluez5-device \
     pulseaudio-module-switch-on-connect \
     pulseaudio-module-loopback \
"
