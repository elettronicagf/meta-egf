PACKAGECONFIG_append = "fontconfig"
