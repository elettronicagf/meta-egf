FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-calibration-for-BLC1081-touchscreen.patch"

