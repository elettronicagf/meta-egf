PRINC = "1"

RDEPENDS_${PN} = "\
    packagegroup-core-x11-xserver \
    packagegroup-core-x11-utils \
    dbus \
    mini-x-session \
    liberation-fonts \
    "
