PRINC = "1"
#Commentati Praticamente tutti i pacchetti sato
RDEPENDS_${PN}-base = ""
RDEPENDS_${PN}-apps = "\
    x11vnc \
    "
RDEPENDS_${PN}-games = ""
