include nano.inc

PR = "${INC_PR}.0"

SRC_URI += "file://ncursesw.includedir.patch"
LICENSE = "LGPLv2.1"

LIC_FILES_CHKSUM = "file://THANKS;md5=54cdb409a70b74d1a8b41a731e0d9ef5"

